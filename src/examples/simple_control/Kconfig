## src/examples/simple_control/Kconfig
```kconfig
menuconfig EXAMPLES_SIMPLE_CONTROL
	bool "simple_control"
	default n
	---help---
		Enable support for simple_control
```
